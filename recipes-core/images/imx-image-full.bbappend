IMAGE_BOOT_FILES:append = " imx93-gis-frdm-dsi.dtb"
