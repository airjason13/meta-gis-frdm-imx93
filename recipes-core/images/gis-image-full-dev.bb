require gis-image-full.bb

IMAGE_FEATURES += "dev-pkgs"
