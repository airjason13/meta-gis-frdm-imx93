FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0010-modify_fdtfile_to_gis.patch"

