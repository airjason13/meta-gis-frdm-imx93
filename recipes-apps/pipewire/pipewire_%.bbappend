
PACKAGECONFIG:append:pn-libspa = " bluetooth"
PACKAGECONFIG:append:pn-pipewire = " \
    bluez5 \
    bluez5-codec-aac \
    bluez5-codec-opus \
    bluez5-codec-lc3 \
"
