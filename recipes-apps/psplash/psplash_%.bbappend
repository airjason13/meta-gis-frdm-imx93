FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-change-background-color.patch \
            file://psplash-poky-img.png \
           "

